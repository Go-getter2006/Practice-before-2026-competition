# Keil uVision project timg_qei_mode_LP_MSPM0G3519_nortos_keil.uvprojx, settings and files
target timg_qei_mode_LP_MSPM0G3519_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  pack: TexasInstruments.MSPM0GX51X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20100000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x00400000,0x00080000) XRAM(0x20200000,0x00020000) XRAM2(0x20300000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: timg_qei_mode_LP_MSPM0G3519_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' timg_qei_mode.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0g3519.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0gx51x/driverlib.a
  group Source
    ../: timg_qei_mode.c timg_qei_mode.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g351x_uvision.s
